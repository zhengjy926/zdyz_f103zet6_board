# Keil uVision project test.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\user;..\applicatios;..\devices;..\drivers\bsp\inc;..\drivers\bsp\stm32;..\drivers\cmsis-device-f1\Include;..\drivers\stm32f1xx-hal-driver\Inc;..\drivers\stm32f1xx-hal-driver\Inc\Legacy;..\utilities;..\utilities\math;..\utilities\filter;..\middlewares\SEGGER_RTT;..\middlewares\proto;..\functions
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c board.c std_user.c stm32f1xx_hal_conf.h sys_config.h
  group applicatios
    ../applicatios/: app.c custom_proto.c
  group functions
    ../functions/: data_mgmt.c loop_impd.c attach_impd.c safety.c operate_loop.c
  group middlewares/SEGGER_RTT
    ../middlewares/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_Conf.h
  group middlewares/proto
    ../middlewares/proto/: serial_proto.c
  group devices
    ../devices/: adc.c gpio.c mtd_core.c pwm.c serial.c watchdog.c key_core.c gpio_key.c
  group drivers/bsp
    ../drivers/bsp/stm32/: stm32_adc.c stm32_gpio.c stm32_flash.c stm32_it.c stm32_iwdg.c stm32_pwm.c stm32_usart.c
  group drivers/stm32f1xx_hal
    ../drivers/stm32f1xx-hal-driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group drivers/cmsis
    ../drivers/cmsis-device-f1/Source/Templates/: system_stm32f1xx.c
    ../drivers/cmsis-device-f1/Source/Templates/arm/: startup_stm32f103xb.s startup_stm32f103xe.s
  group utilities
    ../utilities/: crc.c kfifo.c log.c sort_algo.c stimer.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:Custom 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.1
